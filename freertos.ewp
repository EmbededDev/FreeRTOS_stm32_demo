# IAR project freertos.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: Opts; ; board\; library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; library\STM32F10x_StdPeriph_Driver\inc\; Hal; Bsp; App; library\FreeRTOS\Common\include; library\FreeRTOS\Source\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Opts
  OBJCOPY.OOCOutputFile: freertos.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER; IAR_ARM_CM3
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  group App
    App/: main.c
  group Bsp
    Bsp/: led.c
  group CMSIS
    Hal/: startup_stm32f10x_md_freertos.s
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Config
    ./: readme.txt
    config/: STM32F10x_FLASH.icf STM32F10x_RAM.icf
  group FreeRTOS
    ../library/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../library/FreeRTOS/Source/: list.c queue.c tasks.c
    ../library/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Hal
    Hal/: hal.c hal_gpio.c hal_nvic.c hal_rcc.c hal_uart.c
  group Opts
    Opts/: board.h FreeRTOSConfig.h stm32f10x_conf.h
  group StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Vectors
    App/: stm32f10x_it.c
